# Keil uVision project STM32F103RCT6.uvprojx, settings and files
target Portable Oxygenerator (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: PortableOxygenerator +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\User_Files\Application;.\User_Files\Middle;.\User_Files\Driver;.\User_Files\Common;.\STM32F10x_FWLib\inc;.\CoreSupport;.\startup;.\System
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Applicaiton
    ./User_Files/Application/: AplMain.c
  group Middle
    ./User_Files/Middle/: MidBLDC.c MidModbus.c MidSensor.c MidTime.c MidLCD.c
  group Driver
    ./User_Files/Driver/: DrvADC.c DrvBLE.c DrvCharger.c DrvDAC.c DrvDelay.c DrvFan.c DrvFlash.c DrvFont.c DrvKey.c DrvLCD.c DrvLED.c DrvPictures.c DrvPower.c DrvSMBus.c DrvSPI.c DrvSys.c DrvTimer.c DrvUsart.c DrvVavle.c
  group Common
    ./User_Files/Common/: Common.c
  group System
    ./System/: system_stm32f10x.c
  group Startup
    ./startup/: startup_stm32f10x_hd.s
  group Coresupport
    ./CoreSupport/: core_cm3.c
  group Stm32F10x_fwlib
    ./STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Readme
    ./: readme.c
